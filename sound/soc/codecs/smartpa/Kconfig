## sound/soc/codecs/smartpa/Kconfig
```kconfig
config SND_SOC_SMARTPA
        tristate "smart pa amplifier"
        depends on I2C
```
